# IAR project IIC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: ..\Source; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Include; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries; ..\Source\common; ..\Source\dev
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IIC.hex
  ILINK.IlinkOutputFile: IIC.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Source/: readme.txt
  group Libraries/CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/FWLIB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group Libraries/STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group Source
    ../Source/: lcd.c main.c
  group Source/common
    ../Source/common/: delay.c font.c font_16_st.c fsmc.c ILI93xx.c key.c led.c usart.c
  group Source/dev
    ../Source/dev/: htu21d.c iic.c

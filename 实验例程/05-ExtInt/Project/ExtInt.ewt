<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Source</name>
    <file>
      <name>$PROJ_DIR$\..\Source\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\extint.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\main.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\Source\readme.txt</name>
  </file>
</project>



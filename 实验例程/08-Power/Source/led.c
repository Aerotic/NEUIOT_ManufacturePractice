/*********************************************************************************************
* 文件：led.c
* 作者：Meixin 2017.09.15
* 说明：LED灯驱动代码     
* 修改：liutong 20171027 修改了LED控制引脚初始化函数名称、优化了注释、增加了LED打开和关闭函数
* 注释：
*********************************************************************************************/

/*********************************************************************************************
* 头文件
*********************************************************************************************/
#include "led.h"

/*********************************************************************************************
* 名称：led_init()
* 功能：LED控制引脚初始化
* 参数：无
* 返回：无
* 修改：
* 注释：
*********************************************************************************************/
void led_init(void)
{
  P1SEL &= ~0x03;                                               //配置控制管脚（p1.0, p1.1）为通用IO模式
  P1DIR |= 0x03;                                                //配置控制管脚（p1.0, p1.1）为输出模式
  
  D1 = OFF;                                                     //初始状态为关闭
  D2 = OFF;                                                     //初始状态为关闭
}
  
/*********************************************************************************************
* 名称：led_on()
* 功能：LED控制打开函数
* 参数：LED号，在led.h中宏定义为D1，D2
* 返回：0，打开LED成功，-1，参数错误
* 修改：
* 注释：参数只能填入D1，D2,否则会返回-1
*********************************************************************************************/
signed char led_on(unsigned char led)
{
  if(led == D1){                                                //如果要打开D1
    D1 = ON;
    return 0;
  }
    
  if(led == D2){                                                //如果要打开D2
    D2 = ON;
    return 0;
  }
  
  return -1;                                                    //参数错误，返回-1
}

/*********************************************************************************************
* 名称：led_off()
* 功能：LED控制关闭函数
* 参数：LED号，在led.h中宏定义为D1，D2
* 返回：0，关闭LED成功，-1，参数错误
* 修改：
* 注释：参数只能填入D1，D2,否则会返回-1
*********************************************************************************************/
signed char led_off(unsigned char led)
{
  if(led == D1){                                                //如果要关闭D1
    D1 = OFF;
    return 0;
  }
    
  if(led == D2){                                                //如果要关闭D2
    D2 = OFF;
    return 0;
  }
  
  return -1;                                                    //参数错误，返回-1
}
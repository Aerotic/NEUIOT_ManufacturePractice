<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\..\..\common\at-uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\at.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\example\common\startup_ewarm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\wifi_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\zxbee-inf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\zxbee-sys-command.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\zxbee.c</name>
    </file>
  </group>
  <group>
    <name>dev</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\example\common\gpio_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\dev\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\dev\pinmux.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\dev\relay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\dev\systick_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\example\common\uart_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\dev\ucfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\example\common\udma_if.c</name>
    </file>
  </group>
  <group>
    <name>sensor</name>
    <file>
      <name>$PROJ_DIR$\..\src\BH1750.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\fbm320.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\htu21d.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\iic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\ld3320.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\lis3dh.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\MP-503.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\sensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\sensor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\stadiometry.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\UserAt.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\readme.txt</name>
  </file>
</project>


